# IAR project Project.ewp, settings and files
configuration STM32469I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Drivers\BSP\STM32469I_EVAL; ..\..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\Drivers; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f469xx.s
  group Application/User
    ../Src/: decode.c jdata_conf.c main.c stm32f4xx_it.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_camera.c stm32469i_eval_io.c stm32469i_eval_lcd.c stm32469i_eval_sd.c stm32469i_eval_sdram.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
